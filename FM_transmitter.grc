options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: FM Radio Transmitter
  states: {}

blocks:
- name: sample_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: tx_freq
  id: variable_qtgui_range
  parameters:
    label: Radio Frequency
    start: 88e6
    step: '1000'
    stop: 108e6
    value: '106000000'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: TX Gain
    rangeType: int
    start: '20'
    step: '1'
    stop: '60'
    value: '30'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    alias: FM Transmit
    audio_rate: '1411000'
    fh: '12000'
    max_dev: '16000'
    quad_rate: '1411000'
    tau: '75e-6'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '3'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\Marek\Desktop\FM_TX_GNU_Radio\Richard_Wagner_-_The_Valkyrie_-_Ride_of_the_Valkyries.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: '16000'
    gain: '1'
    interp: '1'
    samp_rate: '480000'
    type: interp_fir_filter_ccf
    width: '12000'
    win: window.WIN_KAISER
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: tx_freq
    fftsize: '4096'
    gui_hint: 0,0,1,2
    label: Gain
    name: FM Signal
    showports: 'True'
    type: complex
    units: dBm
    ymax: '0'
    ymin: '-200'
  states: {}
- name: soapy_limesdr_sink_0
  id: soapy_limesdr_sink
  parameters:
    center_freq: tx_freq
    gain: tx_gain
    samp_rate: sample_rate
    type: fc32
  states: {}

connections:
- [analog_wfm_tx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_wfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_wavfile_source_0, '1', blocks_null_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', soapy_limesdr_sink_0, '0']

metadata:
  file_format: 1
